# Keil uVision project blinky_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\src;..\..\..\src\unix;..\..\..\build\unix
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../src/: NanoVM.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nanovm
    ../../../src/: array.c array.h debug.c debug.h delay.h eeprom.h error.c error.h heap.c heap.h loader.c loader.h native.h native_formatter.c native_formatter.h native_impl.h native_lcd.c native_lcd.h native_math.c native_math.h native_stdio.c native_stdio.h nvmcomm1.c nvmcomm1.h nvmcomm2.c nvmcomm2.h nvmfeatures.h nvmfile.c nvmfile.h nvmstring.c nvmstring.h nvmtypes.h opcodes.h stack.c stack.h types.h uart.c uart.h utils.h vm.c vm.h
  group unix
    ../../../src/unix/: native.h native_impl.c
  group build_unix
    ../../../build/unix/: config.h nvmdefault.h
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
software components: CMSIS:CORE , Board Support:bsp 7.1.0, Device:Startup 1.0.0, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_gpio 1.2.0
