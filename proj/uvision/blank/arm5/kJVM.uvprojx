# Keil uVision project kJVM.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\PLATFORMS\LINUX;..\..\..\..\JVM;..\..\..\..\JAVALANGNATIVE;..\..\..\..\NATIVE_MICROKERNELS\default;..\..\..\..\JVM\java_tests;..\..\..\..\NATIVE_MICROKERNELS\default\binaries
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../../JVM/: kjvm.c kjvm.h
  group JVM
    ../../../../JVM/: classfile.c classfile.h classloader.c classloader.h definitions.h heap.c heap.h interpreter.c interpreter.h limits.h nativedispach.h nativedispatch.c scheduler.c scheduler.h stack.c stack.h typedefinitions.h
  group JAVALANGNATIVE
    ../../../../JAVALANGNATIVE/: float.c float.h interruptthread.c interruptthread.h lock.c lock.h nstring.c nstring.h object.c object.h thread.c thread.h
  group platform
    ../../../../PLATFORMS/LINUX/: config.h debug.h main.c native.c native.h platform.c platform.h
software components: CMSIS:CORE , Board Support:bsp 7.1.0, Device:Startup 1.0.0, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_gpio 1.2.0
