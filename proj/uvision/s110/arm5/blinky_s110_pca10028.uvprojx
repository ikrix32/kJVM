# Keil uVision project blinky_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_NRF6310 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  c misc: --c99 --pointer_alignment=1
  c include: ..\..\..\src;..\..\..\src\unix;..\..\..\build\unix;..\..\..\ble_console;..\..\..\iceq\tests
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../iceq/: KJVM.c
  group nanovm
    ../../../src/: array.c array.h debug.c debug.h error.c error.h heap.c heap.h loader.c loader.h native_formatter.c native_formatter.h native_impl.h native_math.c native_math.h native_stdio.c native_stdio.h nvmfeatures.h nvmfile.c nvmfile.h nvmstring.c nvmstring.h nvmtypes.h opcodes.h stack.c stack.h types.h utils.h vm.c vm.h nvm_mem_access.c nvm_mem_access.h
  group unix
    ../../../src/unix/: native.h native_impl.c
  group build_unix
    ../../../build/unix/: config.h nvmdefault.h
  group ble_console
    ../../../ble_console/: ble_nus.c console.c retarget.c retarget.h
  group tests
    ../../../iceq/tests/: ICMP.h HelloWorld.h Fibonacci.h DivByZero.h AnotherClass.h SelfInstance.h LedBlink.h Inheritance.h
  group ::Board Support
    RTE/Board_Support/nRF51422_xxAC/: bsp.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
  group ::nRF_BLE
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_BLE/1.1.0/common/: ble_srv_common.c
    RTE/nRF_BLE/nRF51422_xxAC/: ble_advdata.c ble_advdata.h ble_conn_params.c ble_conn_params.h
  group ::nRF_Drivers
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/nRF_Drivers/1.2.0/hal/: nrf_delay.c
    RTE/nRF_Drivers/nRF51422_xxAC/: simple_uart.c simple_uart.h
  group ::nRF_Libraries
    RTE/nRF_Libraries/nRF51422_xxAC/: app_button.c app_button.h app_error.c app_error.h app_gpiote.c app_gpiote.h app_scheduler.c app_scheduler.h app_timer.c app_timer.h nrf_assert.c nrf_assert.h
  group ::nRF_SoftDevice
    RTE/nRF_SoftDevice/nRF51422_xxAC/: softdevice_handler.c
software components: CMSIS:CORE , Board Support:bsp 7.1.0, Device:Startup 1.0.1, nRF_BLE:BLE_Modules:ble_advdata 1.1.0, nRF_BLE:BLE_Modules:ble_conn_params 1.1.0, nRF_BLE:BLE_Modules:ble_service_common 1.1.0, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:simple_uart 1.2.0, nRF_Libraries:app_button 1.1.0, nRF_Libraries:app_error 1.1.0, nRF_Libraries:app_gpiote 1.1.0, nRF_Libraries:app_scheduler 1.1.0, nRF_Libraries:app_timer 1.1.0, nRF_Libraries:app_util 1.1.0, nRF_Libraries:nrf_assert 1.1.0, nRF_SoftDevice:Internal:sd_common 1.1.0, nRF_SoftDevice:Internal:softdevice_present 1.1.0, nRF_SoftDevice:s110 7.1.0-3
