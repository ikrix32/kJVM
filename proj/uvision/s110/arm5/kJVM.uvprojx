# Keil uVision project kJVM.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_NRF6310 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  c misc: --c99 --pointer_alignment=1
  c include: ..\..\..\src;..\..\..\src\unix;..\..\..\build\unix;..\..\..\ble_console;..\..\..\iceq\tests
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../iceq/: KJVM.c
  group nanovm
    ../../../src/: array.c array.h debug.c debug.h error.c error.h heap.c heap.h loader.c loader.h native_formatter.c native_formatter.h native_impl.h native_math.c native_math.h native_stdio.c native_stdio.h nvmfeatures.h nvmfile.c nvmfile.h nvmstring.c nvmstring.h nvmtypes.h opcodes.h stack.c stack.h types.h utils.h vm.c vm.h nvm_mem_access.c nvm_mem_access.h
  group unix
    ../../../src/unix/: native.h native_impl.c
  group build_unix
    ../../../build/unix/: config.h nvmdefault.h
  group ble_console
    ../../../ble_console/: ble_nus.c console.c retarget.c retarget.h
  group tests
    ../../../iceq/tests/: ICMP.h HelloWorld.h Fibonacci.h DivByZero.h AnotherClass.h SelfInstance.h LedBlink.h Inheritance.h
software components: CMSIS:CORE 3.40.0, Board Support:bsp 7.1.0, Device:Startup 1.0.1, nRF_BLE:BLE_Modules:ble_advdata 1.1.1, nRF_BLE:BLE_Modules:ble_conn_params 1.1.1, nRF_BLE:BLE_Modules:ble_service_common 1.1.1, nRF_Drivers:nrf_delay 1.2.0, nRF_Drivers:nrf_error 1.2.0, nRF_Drivers:nrf_gpio 1.2.0, nRF_Drivers:simple_uart 1.2.0, nRF_Libraries:app_button 1.1.1, nRF_Libraries:app_error 1.1.1, nRF_Libraries:app_gpiote 1.1.1, nRF_Libraries:app_scheduler 1.1.1, nRF_Libraries:app_timer 1.1.1, nRF_Libraries:app_util 1.1.1, nRF_Libraries:nrf_assert 1.1.1, nRF_SoftDevice:Internal:sd_common 1.1.0, nRF_SoftDevice:Internal:softdevice_present 1.1.0, nRF_SoftDevice:s110 7.1.0-3
